# Keil uVision project carcube.uvprojx, settings and files
target carcube (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: carcube +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\carcube\carcube.bin .\carcube\carcube.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;                                                                                        ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                        ../Drivers/CMSIS/Include;                                                                                        ..\qcloud-iot-sdk-tencent-at-based\include;                                                                                        ..\qcloud-iot-sdk-tencent-at-based\src\include;                                                                                        ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                                        ..\HARDWEAR\inc
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: retarget.c main.c gpio.c freertos.c dcmi.c dma.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group qcloud-iot-sdk-tencent-at-based
    ../qcloud-iot-sdk-tencent-at-based/port/: hal_at.c hal_os.c
    ../qcloud-iot-sdk-tencent-at-based/src/data_template/: data_template_aciton.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
    ../qcloud-iot-sdk-tencent-at-based/src/module_at/: at_client.c at_utils.c at_log.c at_timer.c iot_device.c module_api_inf.c ringbuff.c
    ../qcloud-iot-sdk-tencent-at-based/src/mqtt/: mqtt.c
    ../qcloud-iot-sdk-tencent-at-based/src/utils/: json_parser.c json_token.c string_utils.c utils_list.c utils_timer.c
  group mqtt_sample
    ../qcloud-iot-sdk-tencent-at-based/sample/: mqtt_sample.c
  group data_tamplate_sample
    ../qcloud-iot-sdk-tencent-at-based/usr_logic/: data_template_usr_logic.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HARDWEAR
    ../HARDWEAR/src/: move.c pwm.c encode.c pid.c ov2640.c sccb.c img.c esp8266.c init.c
software components: CMSIS:CORE 5.4.0
